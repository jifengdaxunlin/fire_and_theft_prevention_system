# Keil uVision project fire_theif_proof.uvprojx, settings and files
target F407VE (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fire_theif_proof +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\app;..\board;..\bsp;..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\module;..\bsp;..\Net;..\FreeRTOS\src;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\FreeRTOS\port\MemMang;..\board\ADC;..\board\BEEP;..\board\DELAY;..\board\DMA;..\board\DHT11;..\board\DMA;..\board\EEPROM;..\board\EXIT;..\board\FAN;..\board\IIC;..\board\IR;..\board\IWDG;..\board\KEY;..\board\LED;..\board\light_adc;..\board\MQ-2;..\board\OLED;..\board\PIR;..\board\RGB;..\board\RTC;..\board\Steering_Gear;..\board\STIM1;..\board\TIM6;..\board\TIM7;..\board\USART;..\board\Water;..\libraries\STM32F4xx_StdPeriph_Driver\src;..\libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../app/: main.c
  group STARTUP
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group Board
    ../board/: board.c
    ../board/ADC/: ADC.c
    ../board/BEEP/: BEEP.c
    ../board/DELAY/: DELAY.c
    ../board/DHT11/: DHT11.c
    ../board/DMA/: DMA.c
    ../board/EEPROM/: EEPROM.c
    ../board/EXIT/: EXTI.c
    ../board/FAN/: FAN.c
    ../board/IIC/: IIC.c
    ../board/IR/: IR.c
    ../board/IWDG/: IWDG.c
    ../board/LED/: LED.c
    ../board/light_adc/: light_adc.c
    ../board/MQ-2/: MQ2.c
    ../board/OLED/: OLED.c
    ../board/PIR/: PIR.c
    ../board/RGB/: RGB.c
    ../board/RTC/: RTC.c
    ../board/Steering_Gear/: Steering_Gear.c
    ../board/STIM1/: STIM1.c
    ../board/TIM7/: TIM7.c
    ../board/USART/: USART.c
    ../board/Water/: Water.c
    ../board/TIM6/: TIM6.c
    ../board/KEY/: KEY.c
  group Driver
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group MODULE
    ../module/: stm32f4xx_it.c
  group NET
    ../Net/: esp8266.c mqtt.c
  group FreeRTOS
    ../FreeRTOS/src/: list.c queue.c tasks.c timers.c croutine.c event_groups.c stream_buffer.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
